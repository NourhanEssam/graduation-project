# Keil uVision project Traffic_Light.uvproj, settings and files
target TL (ARM-ADS)
  device: TM4C1231C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Traffic_Light
  c flags: Optim=1 wLevel=2
  c include: C:\Keil\Labware
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: GSM.c main.c PLL.c SysTick.c UART.c GSM.h PLL.h SysTick.h tm4c123gh6pm.h UART.h startup_TM4C123.s
